Commit message: init

File: models/block/block_markers.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- link block: geometry collision box size=0.04 0.04 0.04; visual box size=0.04 0.04 0.04
